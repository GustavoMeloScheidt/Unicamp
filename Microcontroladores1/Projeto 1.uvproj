# Keil uVision project Projeto 1.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S8252 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000) MODA2
  output: Projeto 1
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: Exemplo1.asm Exemplo2.asm
